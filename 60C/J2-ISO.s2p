!Agilent Technologies,N5230A,US43500212,A.07.50.67
!Agilent N5230A: A.07.50.67
!Date: Monday, September 22, 2025 06:00:46
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 18 GHz to 42 GHz, reference 50 ohm
!   highest |S21| = -65.58 dB at 42 GHz (marker M1); lowest = -111.4 dB at 21.24 GHz (marker M2)
!   lowest |S11| = -58.0 dB at 31.08 GHz (marker M3), VSWR 1.00, Z = 50.1 - j0.108 ohm
!   |S11| at or under -10 dB: start of sweep to 28.92 GHz; 28.92 GHz to 32.69 GHz (3.763 GHz wide, 12.2 % of centre); 33.82 GHz to end of sweep
!   |S22| runs from -4.3 to -2.1 dB; largest |S21 - S12| = 5.6e-05
!   the Smith chart shows 28.8 GHz to 33.6 GHz only
!   S11 on the Smith chart (normalised r, x): 28.8 GHz: 0.52, -0.05; 29.52 GHz: 0.82, +0.47; 30.84 GHz: 1.07, -0.03; 32.4 GHz: 1.62, +0.37; 33 GHz: 1.31, -0.78; 33.6 GHz: 0.60, -0.39
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 18 GHz  -12.0  -76.0  -75.9  -3.5
! 20.28 GHz  -26.5  -90.3  -89.7  -3.0
! 21.24 GHz  -17.9  -111.4  -100.3  -2.6
! 22.08 GHz  -14.7  -100.0  -111.6  -2.3
! 26.04 GHz  -20.0  -93.7  -90.1  -2.2
! 28.8 GHz  -10.1  -84.1  -84.1  -2.8
! 29.52 GHz  -11.5  -83.8  -82.5  -3.1
! 30 GHz  -15.0  -82.8  -82.5  -3.6
! 30.84 GHz  -29.4  -81.3  -81.7  -4.3
! 31.08 GHz  -58.0  -80.1  -79.5  -4.3
! 31.32 GHz  -28.3  -78.4  -79.8  -4.3
! 32.4 GHz  -11.3  -77.3  -79.2  -3.8
! 33 GHz  -9.2  -78.6  -77.9  -3.4
! 33.6 GHz  -9.4  -75.7  -75.6  -3.1
! 34.08 GHz  -11.1  -73.7  -74.0  -2.9
! 38.04 GHz  -17.8  -92.7  -90.5  -3.1
! 38.4 GHz  -29.0  -88.1  -97.7  -3.1
! 40.2 GHz  -12.8  -86.6  -88.1  -3.3
! 40.8 GHz  -21.5  -86.6  -84.6  -3.6
! 41.04 GHz  -38.0  -82.7  -85.2  -3.7
! 41.4 GHz  -20.7  -77.4  -77.4  -3.8
! 42 GHz  -19.2  -65.6  -64.8  -4.1
