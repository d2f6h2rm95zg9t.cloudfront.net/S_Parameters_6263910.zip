!Agilent Technologies,N5230A,US43500212,A.07.50.67
!Agilent N5230A: A.07.50.67
!Date: Monday, September 22, 2025 06:02:15
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 18 GHz to 42 GHz, reference 50 ohm
!   highest |S21| = -66.09 dB at 42 GHz (marker M1); lowest = -107.7 dB at 21 GHz (marker M2)
!   lowest |S11| = -41.7 dB at 20.52 GHz (marker M3), VSWR 1.02, Z = 49.2 + j0.0215 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -3.3 to -2.0 dB; largest |S21 - S12| = 6.1e-05
!   the Smith chart shows 18.36 GHz to 22.8 GHz only
!   S11 on the Smith chart (normalised r, x): 18.36 GHz: 0.83, -0.45; 19.08 GHz: 0.67, +0.03; 19.92 GHz: 1.03, +0.18; 22.2 GHz: 1.45, +0.42; 22.8 GHz: 1.57, -0.49
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 18 GHz  -11.4  -75.5  -75.7  -3.1
! 18.36 GHz  -11.9  -75.6  -74.9  -3.0
! 19.08 GHz  -14.1  -75.2  -74.9  -2.8
! 19.92 GHz  -20.8  -90.7  -103.0  -2.7
! 20.52 GHz  -41.7  -103.1  -97.2  -2.5
! 21 GHz  -21.3  -107.7  -108.2  -2.3
! 22.08 GHz  -12.6  -97.9  -106.7  -2.1
! 22.2 GHz  -12.1  -93.8  -102.8  -2.0
! 22.8 GHz  -10.8  -99.1  -100.0  -2.1
! 26.04 GHz  -16.0  -98.1  -98.7  -2.2
! 28.68 GHz  -19.7  -91.0  -88.8  -2.1
! 29.4 GHz  -32.9  -92.4  -90.6  -2.2
! 30 GHz  -18.2  -89.0  -87.6  -2.4
! 34.08 GHz  -15.4  -78.5  -79.3  -3.1
! 36.12 GHz  -19.6  -79.9  -79.3  -2.9
! 37.2 GHz  -11.0  -82.1  -81.9  -3.2
! 38.04 GHz  -19.5  -80.8  -84.2  -2.9
! 38.28 GHz  -30.3  -82.9  -81.6  -2.8
! 39.24 GHz  -13.3  -81.4  -80.1  -2.4
! 40.56 GHz  -25.2  -81.1  -79.2  -2.6
! 41.04 GHz  -16.7  -81.2  -78.4  -2.7
! 42 GHz  -21.7  -66.1  -66.2  -3.0
