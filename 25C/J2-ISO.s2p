!Agilent Technologies,N5230A,US43500212,A.07.50.67
!Agilent N5230A: A.07.50.67
!Date: Monday, September 22, 2025 05:43:52
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 18 GHz to 42 GHz, reference 50 ohm
!   highest |S21| = -65.20 dB at 42 GHz (marker M1); lowest = -112.3 dB at 22.44 GHz (marker M2)
!   lowest |S11| = -42.0 dB at 41.04 GHz (marker M3), VSWR 1.02, Z = 50.7 - j0.348 ohm
!   |S11| at or under -10 dB: start of sweep to 32.75 GHz; 33.7 GHz to end of sweep
!   |S22| runs from -4.2 to -2.0 dB; largest |S21 - S12| = 5e-05
!   the Smith chart shows 37.68 GHz to 42 GHz only
!   S11 on the Smith chart (normalised r, x): 37.68 GHz: 1.41, -0.27; 39.36 GHz: 0.99, -0.52; 39.96 GHz: 0.60, -0.07; 42 GHz: 1.09, +0.21
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 18 GHz  -11.6  -76.0  -76.1  -3.4
! 18.96 GHz  -14.0  -72.5  -72.3  -3.2
! 20.28 GHz  -26.3  -90.2  -89.3  -2.9
! 22.08 GHz  -14.6  -105.1  -104.3  -2.3
! 22.44 GHz  -13.7  -112.3  -100.8  -2.3
! 26.04 GHz  -21.5  -90.7  -88.2  -2.2
! 28.56 GHz  -10.1  -84.2  -84.9  -2.7
! 30 GHz  -15.2  -81.6  -82.0  -3.6
! 31.2 GHz  -39.2  -78.8  -79.9  -4.2
! 31.56 GHz  -22.3  -77.2  -78.2  -4.0
! 32.16 GHz  -13.2  -78.4  -78.9  -3.7
! 34.08 GHz  -11.7  -73.2  -73.2  -2.8
! 37.68 GHz  -13.9  -91.6  -86.3  -3.1
! 38.04 GHz  -17.7  -94.2  -103.8  -3.0
! 38.4 GHz  -28.8  -89.7  -91.0  -3.0
! 39.36 GHz  -11.9  -92.8  -87.0  -2.8
! 39.96 GHz  -11.9  -92.2  -90.8  -3.1
! 40.68 GHz  -18.3  -87.2  -86.0  -3.4
! 40.92 GHz  -26.3  -85.6  -84.8  -3.5
! 41.04 GHz  -42.0  -83.0  -88.6  -3.6
! 41.28 GHz  -23.2  -79.1  -80.8  -3.7
! 42 GHz  -19.3  -65.2  -64.6  -4.1
