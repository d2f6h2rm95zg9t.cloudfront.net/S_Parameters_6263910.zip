!Agilent Technologies,N5230A,US43500212,A.07.50.67
!Agilent N5230A: A.07.50.67
!Date: Monday, September 22, 2025 05:45:43
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 18 GHz to 42 GHz, reference 50 ohm
!   highest |S21| = -66.64 dB at 42 GHz (marker M1); lowest = -112.7 dB at 21.12 GHz (marker M2)
!   lowest |S11| = -41.6 dB at 20.4 GHz (marker M3), VSWR 1.02, Z = 50.4 + j0.714 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -3.1 to -2.0 dB; largest |S21 - S12| = 5.9e-05
!   the Smith chart shows 18.24 GHz to 22.56 GHz only
!   S11 on the Smith chart (normalised r, x): 18.24 GHz: 0.93, -0.53; 18.84 GHz: 0.65, -0.12; 19.56 GHz: 0.85, +0.22; 21.96 GHz: 1.19, +0.46; 22.56 GHz: 1.76, -0.10
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 18 GHz  -11.1  -75.8  -76.2  -3.0
! 18.24 GHz  -11.5  -75.1  -74.7  -2.9
! 18.84 GHz  -13.1  -72.2  -71.7  -2.8
! 19.56 GHz  -16.9  -87.4  -86.0  -2.7
! 20.16 GHz  -25.9  -88.5  -91.4  -2.5
! 20.4 GHz  -41.6  -92.1  -92.5  -2.4
! 21.12 GHz  -19.2  -112.7  -101.0  -2.2
! 21.96 GHz  -13.1  -95.4  -99.7  -2.0
! 22.08 GHz  -12.6  -98.8  -97.7  -2.0
! 22.56 GHz  -11.1  -94.2  -101.6  -2.0
! 26.04 GHz  -17.0  -91.7  -90.0  -2.2
! 29.28 GHz  -29.0  -89.4  -87.9  -2.2
! 30 GHz  -16.8  -91.0  -87.3  -2.4
! 34.08 GHz  -16.3  -79.6  -78.7  -2.9
! 36.12 GHz  -19.5  -79.1  -79.7  -2.8
! 37.2 GHz  -10.8  -82.2  -80.8  -3.1
! 38.04 GHz  -19.8  -80.6  -82.1  -2.8
! 38.28 GHz  -30.5  -79.9  -82.3  -2.7
! 39 GHz  -13.8  -81.9  -81.4  -2.4
! 40.56 GHz  -24.6  -82.1  -78.4  -2.6
! 41.16 GHz  -15.1  -81.1  -82.7  -2.8
! 42 GHz  -21.7  -66.6  -66.0  -3.1
