!Agilent Technologies,N5230A,US43500212,A.07.50.67
!Agilent N5230A: A.07.50.67
!Date: Monday, September 22, 2025 05:52:34
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 18 GHz to 42 GHz, reference 50 ohm
!   highest |S21| = -64.84 dB at 42 GHz (marker M1); lowest = -111.9 dB at 21.72 GHz (marker M2)
!   lowest |S11| = -36.8 dB at 31.2 GHz (marker M3), VSWR 1.03, Z = 50.8 + j1.2 ohm
!   |S11| at or under -10 dB: start of sweep to 28.56 GHz; 28.63 GHz to 32.8 GHz (4.166 GHz wide, 13.6 % of centre); 33.48 GHz to end of sweep
!   |S22| runs from -4.1 to -2.0 dB; largest |S21 - S12| = 4.2e-05
!   the Smith chart shows 28.92 GHz to 33.72 GHz only
!   S11 on the Smith chart (normalised r, x): 28.92 GHz: 0.53, -0.00; 29.64 GHz: 0.88, +0.42; 31.56 GHz: 0.95, +0.13; 32.52 GHz: 1.79, +0.10; 33.12 GHz: 1.04, -0.71; 33.72 GHz: 0.60, -0.25
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 18 GHz  -10.9  -76.2  -76.5  -3.3
! 19.08 GHz  -14.0  -72.0  -71.9  -3.1
! 20.28 GHz  -26.9  -87.6  -87.3  -2.8
! 21.72 GHz  -14.9  -111.9  -99.6  -2.3
! 22.08 GHz  -14.1  -101.8  -103.7  -2.2
! 26.04 GHz  -24.4  -88.6  -92.7  -2.3
! 28.92 GHz  -10.2  -83.7  -84.4  -2.8
! 29.64 GHz  -12.8  -82.0  -82.7  -3.3
! 30 GHz  -15.7  -80.9  -82.0  -3.6
! 31.2 GHz  -36.8  -79.6  -79.3  -4.1
! 31.56 GHz  -22.6  -78.1  -78.0  -3.9
! 32.52 GHz  -10.9  -78.6  -77.6  -3.4
! 33.12 GHz  -9.6  -77.0  -75.4  -3.1
! 33.72 GHz  -10.7  -73.4  -73.3  -2.8
! 34.08 GHz  -12.7  -73.2  -72.9  -2.7
! 38.04 GHz  -18.8  -88.1  -91.9  -3.0
! 38.4 GHz  -26.7  -90.5  -95.6  -2.9
! 39 GHz  -13.1  -93.1  -104.5  -2.8
! 40.2 GHz  -12.9  -89.1  -89.5  -3.2
! 41.04 GHz  -33.6  -82.9  -84.6  -3.5
! 41.4 GHz  -19.0  -80.2  -80.7  -3.7
! 42 GHz  -19.9  -64.8  -64.7  -4.1
