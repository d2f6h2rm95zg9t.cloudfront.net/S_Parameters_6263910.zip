!Agilent Technologies,N5230A,US43500212,A.07.50.67
!Agilent N5230A: A.07.50.67
!Date: Monday, September 22, 2025 05:54:17
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   201 points, 18 GHz to 42 GHz, reference 50 ohm
!   highest |S21| = -66.71 dB at 42 GHz (marker M1); lowest = -108.0 dB at 22.2 GHz (marker M2)
!   lowest |S11| = -39.6 dB at 20.4 GHz (marker M3), VSWR 1.02, Z = 49 + j0.404 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -3.1 to -1.9 dB; largest |S21 - S12| = 7e-05
!   the Smith chart shows 18.24 GHz to 22.56 GHz only
!   S11 on the Smith chart (normalised r, x): 18.24 GHz: 0.92, -0.55; 18.84 GHz: 0.64, -0.13; 19.56 GHz: 0.86, +0.22; 21.96 GHz: 1.23, +0.48; 22.56 GHz: 1.77, -0.15
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 18 GHz  -10.6  -76.0  -75.6  -2.9
! 18.24 GHz  -11.0  -75.2  -75.1  -2.8
! 18.84 GHz  -12.8  -72.1  -71.9  -2.7
! 19.56 GHz  -17.2  -83.7  -83.7  -2.5
! 20.4 GHz  -39.6  -94.2  -90.1  -2.3
! 20.76 GHz  -23.1  -95.4  -92.6  -2.2
! 21.96 GHz  -12.7  -100.3  -107.0  -1.9
! 22.08 GHz  -12.2  -106.7  -99.0  -1.9
! 22.2 GHz  -11.8  -108.0  -98.4  -1.9
! 22.56 GHz  -11.0  -95.4  -101.6  -2.0
! 26.04 GHz  -18.8  -89.2  -90.7  -2.2
! 26.88 GHz  -30.6  -89.3  -88.2  -2.4
! 27.6 GHz  -19.5  -92.6  -92.7  -2.4
! 30 GHz  -14.7  -91.4  -88.9  -2.4
! 34.08 GHz  -17.2  -78.2  -79.6  -2.8
! 37.08 GHz  -10.5  -80.9  -80.2  -3.0
! 38.04 GHz  -22.1  -81.3  -81.0  -2.7
! 38.28 GHz  -28.5  -85.1  -81.7  -2.6
! 39.36 GHz  -12.5  -81.2  -84.0  -2.3
! 40.44 GHz  -24.1  -78.7  -78.5  -2.5
! 41.16 GHz  -14.5  -79.8  -80.5  -2.8
! 42 GHz  -22.8  -66.7  -65.9  -3.1
